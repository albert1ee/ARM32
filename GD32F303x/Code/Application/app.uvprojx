# Keil uVision project app.uvprojx, settings and files
target GD32F30X_CL (6160000::V6.16::ARMCLANG)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\User\system;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ./User/: main.c gd32f30x_it.c systick.c system.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group rt-thread
    ./rt-thread/bsp/: rtconfig.h board.c
    ./rt-thread/components/finsh/: finsh_config.h cmd.c finsh.h finsh_api.h finsh_port.c msh.c msh.h shell.c shell.h
    ./rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ./rt-thread/components/device/: device.c
    ./rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group lib
    ./Utilities/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./Utilities/Key/: Key.c sl_list.c
    ./Utilities/flashfs/: ext_flash.c ffsystem.c flashfs.c
    ./Utilities/fifolist/: fifolist.c
    ./Utilities/ymodem/: ymodem.c ymodemapp.c
  group hardware
    ./Hardware/: powerKey.c fatfs.c powerboard.c sync_upload.c flash.c
    ./Utilities/flashfs/: ext_flash.c flashfs.c
target GD32F30X_HD (6160000::V6.16::ARMCLANG)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\User;.\rt-thread\bsp;.\rt-thread\include;.\rt-thread\include\libc;.\rt-thread\components\finsh;.\Utilities\RTT;.\Utilities\Key;.\Utilities\flashfs;.\Utilities\fifolist;.\Utilities\ymodem;.\Hardware;.\Hardware\spiflash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F30X_XD (6160000::V6.16::ARMCLANG)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2002FFFF)IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\User;.\User\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
